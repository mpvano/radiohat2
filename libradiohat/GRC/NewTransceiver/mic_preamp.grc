options:
  parameters:
    generate_options: hb
    id: mic_preamp
    output_language: python
    title: Mic Preamp
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ALSA
  id: parameter
  parameters:
    label: SELECT_ALSA
    value: '0'
  states: {}
- name: MuteMic
  id: parameter
  parameters:
    label: MUTE_MIC
    value: '0'
  states: {}
- name: PTT
  id: parameter
  parameters:
    label: PTT
    value: '0'
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: 1e0
    gain: 0.3 * PTT
    max_gain: '0.6'
    reference: '0.3'
    type: float
  states: {}
- name: blocks_add_xx_4
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 0 if ALSA else 16
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 8 if ALSA else 0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-MuteMic
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: MicPreamp
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: fromCodec
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: FromALSA
    type: float
  states: {}

connections:
- [analog_agc2_xx_1, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_add_xx_4, '0', analog_agc2_xx_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_4, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_4, '1']
- [blocks_multiply_const_vxx_3_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [pad_source_1, '0', blocks_multiply_const_vxx_3, '0']

metadata:
  file_format: 1
