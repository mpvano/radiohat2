options:
  parameters:
    generate_options: hb
    id: ssb_demod
    output_language: python
    title: ssb_demodulator
  states: {}

blocks:
- name: LSB
  id: parameter
  parameters:
    label: LSB_SWITCH
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '201'
    win: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '201'
    win: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Demod_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: LeftIn
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: RightIn
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMP_RATE
    value: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '1']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [hilbert_fc_1, '0', blocks_complex_to_real_0, '0']
- [pad_source_0, '0', hilbert_fc_1, '0']
- [pad_source_1, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
