options:
  parameters:
    generate_options: hb
    id: ssb_mod
    output_language: python
    title: ssb modulator
  states: {}

blocks:
- name: LSB
  id: parameter
  parameters:
    label: LSB
    value: '0'
  states: {}
- name: PTT
  id: parameter
  parameters:
    label: PTT
    value: '0'
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    gain: 1 if PTT else 0
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB
    type: float
  states: {}
- name: hilbert_fc_1_0
  id: hilbert_fc
  parameters:
    num_taps: '201'
    win: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: 1- txbalance/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: 1+txbalance/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: SSB_Left
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: SSB_Right
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: AudioIn
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMP_RATE
    value: '0'
  states: {}
- name: txbalance
  id: parameter
  parameters:
    label: TXBALANCE
    value: '0'
  states: {}

connections:
- [band_pass_filter_1, '0', hilbert_fc_1_0, '0']
- [blocks_complex_to_imag_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_complex_to_real_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', low_pass_filter_0, '0']
- [hilbert_fc_1_0, '0', blocks_complex_to_imag_1, '0']
- [hilbert_fc_1_0, '0', blocks_complex_to_real_1, '0']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [low_pass_filter_0_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', band_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
