options:
  parameters:
    generate_options: qt_gui
    id: FMTest
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: KQ2H_squelch29_620m
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '146.2'
    gate: 'False'
    len: '0'
    level: '0.01'
    ramp: '0'
    rate: samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:RadioHatCodec,1
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.1'
    type: float
  states: {}

connections:
- [KQ2H_squelch29_620m, '0', blocks_multiply_const_xx_0, '0']
- [analog_nbfm_rx_0, '0', KQ2H_squelch29_620m, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
