options:
  parameters:
    generate_options: qt_gui
    id: headset
    output_language: python
  states: {}

blocks:
- name: HPF
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:1,1
    label: Low pass
    orient: Qt.Horizontal
    start: '300'
    step: '50'
    stop: '3000'
    value: '2750'
    widget: counter
  states: {}
- name: LPF
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:1,0
    label: High pass
    orient: Qt.Horizontal
    start: '50'
    step: '10'
    stop: '1000'
    value: '50'
    widget: counter
  states: {}
- name: MuteMic
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: RXTXTabs@1:0,2
    label: Mute Mic
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: TXTone
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: RXTXTabs@2:0,3
    label: Tone to TX
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: ToneFreq
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@2:0,1
    label: Tone Freq
    min_len: '1'
    orient: Qt.Vertical
    start: '10'
    step: '10'
    stop: '10000'
    value: '1000'
    widget: counter
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 'RXTXTabs@2: 0,0'
    label: Tone Level
    min_len: '1'
    orient: Qt.Vertical
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.25'
    widget: counter
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:0,0
    label: Gain
    min_len: '0'
    orient: Qt.Vertical
    start: '0'
    step: '.01'
    stop: '0.5'
    value: '0.1'
    widget: dial
  states: {}
- name: agcGain
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:0,1
    label: Volume
    min_len: '5'
    orient: Qt.Vertical
    start: '0.03'
    step: '.01'
    stop: '5'
    value: '1'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: MuteIfNotRX
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gpiozero import Button
      import RPi.GPIO as GPIO


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""


          def __init__(self, example_param=22):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              GPIO.setwarnings(False)
              GPIO.setmode(GPIO.BCM)
              GPIO.setup(self.example_param, GPIO.OUT)


          def work(self, input_items, output_items):
              """example: multiply with constant"""
      #        output_items[0][:] = input_items[0] * self.example_param
              if GPIO.input(self.example_param):
                  output_items[0][:] = 0
              else:
                  output_items[0][:] = input_items[0] * 1.0
              return len(output_items[0])
    example_param: '23'
  states: {}
- name: MuteIfNotSK
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gpiozero import Button
      import RPi.GPIO as GPIO


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""


          def __init__(self, example_param=22):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              GPIO.setwarnings(False)
              GPIO.setmode(GPIO.BCM)
              GPIO.setup(self.example_param, GPIO.IN,pull_up_down=GPIO.PUD_UP )


          def work(self, input_items, output_items):
              """example: multiply with constant"""
      #        output_items[0][:] = input_items[0] * self.example_param
              if GPIO.input(self.example_param):
                  output_items[0][:] = 0
              else:
                  output_items[0][:] = input_items[0] * 1.0
              return len(output_items[0])
    example_param: '26'
  states: {state: bypassed}
- name: MuteIfNotTX
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gpiozero import Button
      import RPi.GPIO as GPIO


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""


          def __init__(self, example_param=22):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              GPIO.setwarnings(False)
              GPIO.setmode(GPIO.BCM)
              GPIO.setup(self.example_param, GPIO.OUT)


          def work(self, input_items, output_items):
              """example: multiply with constant"""
      #        output_items[0][:] = input_items[0] * self.example_param
              if GPIO.input(self.example_param):
                  output_items[0][:] = 0
              else:
                  output_items[0][:] = input_items[0] * 1.0
              return len(output_items[0])
    example_param: '22'
  states: {}
- name: RXTXTabs
  id: qtgui_tab_widget
  parameters:
    label0: Receiver
    label1: Transmitter
    label2: TX Tone
    num_tabs: '3'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: agcGain
    reference: '1.7'
    type: float
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: 1e0
    gain: '0.8'
    max_gain: '8'
    reference: '.8'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel * TXTone
    freq: ToneFreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:RadioHatCodec,0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:RadioHatCodec,1
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Volume
    high_cutoff_freq: HPF
    low_cutoff_freq: LPF
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_mute_xx_1
  id: blocks_mute_xx
  parameters:
    mute: MuteMic
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '131'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '131'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1_0
  id: hilbert_fc
  parameters:
    num_taps: '301'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: RXTXTabs@0:2,0,1,2
    label: level
    legend: 'False'
    showports: 'True'
    type: complex
    units: dBm
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-110'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: RXTXTabs@1:0,0,1,1
    label1: ''
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.05'
  states: {}

connections:
- [MuteIfNotRX, '0', blocks_add_xx_1_0, '0']
- [MuteIfNotRX, '0', blocks_add_xx_1_1, '0']
- [MuteIfNotSK, '0', blocks_complex_to_imag_1, '0']
- [MuteIfNotSK, '0', blocks_complex_to_real_1, '0']
- [MuteIfNotTX, '0', analog_agc2_xx_1, '0']
- [analog_agc2_xx_0, '0', blocks_throttle_0, '0']
- [analog_agc2_xx_1, '0', blocks_mute_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_1, '1']
- [audio_source_0, '0', MuteIfNotTX, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '0', hilbert_fc_1, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', hilbert_fc_0, '0']
- [band_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [band_pass_filter_1, '0', hilbert_fc_1_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_1, '0', band_pass_filter_1, '0']
- [blocks_add_xx_1_0, '0', audio_sink_0, '0']
- [blocks_add_xx_1_1, '0', audio_sink_0, '1']
- [blocks_complex_to_imag_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_imag_1, '0', low_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_real_1, '0', low_pass_filter_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_mute_xx_1, '0', blocks_add_xx_1, '0']
- [blocks_throttle_0, '0', MuteIfNotRX, '0']
- [blocks_throttle_0_0, '0', MuteIfNotSK, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [hilbert_fc_1, '0', blocks_complex_to_real_0, '0']
- [hilbert_fc_1_0, '0', blocks_throttle_0_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_1_0, '1']
- [low_pass_filter_0_0, '0', blocks_add_xx_1_1, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
