options:
  parameters:
    generate_options: qt_gui
    id: alsadefault
    output_language: python
  states: {}

blocks:
- name: HPF
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:1,1
    label: Low pass
    orient: Qt.Horizontal
    start: '300'
    step: '50'
    stop: '3000'
    value: '2750'
    widget: counter
  states: {}
- name: LPF
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:1,0
    label: High pass
    orient: Qt.Horizontal
    start: '50'
    step: '10'
    stop: '1000'
    value: '50'
    widget: counter
  states: {}
- name: LSB
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    gui_hint: RXTXTabs@0:0,2
    label: Reverse Sideband
    'true': '-1'
    type: int
    value: '1'
  states: {}
- name: MuteMic
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: RXTXTabs@1:0,1
    label: Mute Mic
    'true': '1'
    type: real
    value: '1'
  states: {}
- name: TXTone
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: RXTXTabs@1:0,2
    label: Tone to TX
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: ToneFreq
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@1:1,1
    label: Freq
    min_len: '0'
    orient: Qt.Vertical
    start: '10'
    step: '10'
    stop: '10000'
    value: '1000'
    widget: counter
  states: {}
- name: ToneLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 'RXTXTabs@1: 1,0'
    label: Level
    min_len: '0'
    orient: Qt.Vertical
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.5'
    widget: counter
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:0,0
    label: Gain
    min_len: '0'
    orient: Qt.Vertical
    start: '0'
    step: '.01'
    stop: '0.5'
    value: '0.1'
    widget: dial
  states: {}
- name: agcGain
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:0,1
    label: Volume
    min_len: '5'
    orient: Qt.Vertical
    start: '0.03'
    step: '.01'
    stop: '5'
    value: '1'
    widget: dial
  states: {}
- name: rxbalance
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@0:1,2
    label: balance
    min_len: '1'
    orient: Qt.Vertical
    start: '-1'
    step: '.001'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: txbalance
  id: variable_qtgui_range
  parameters:
    gui_hint: RXTXTabs@1:1,2
    label: balance
    min_len: '0'
    orient: Qt.Vertical
    start: '-1'
    step: '.001'
    stop: '1'
    value: '0'
    widget: counter
  states: {}
- name: RXTXTabs
  id: qtgui_tab_widget
  parameters:
    label0: Receiver
    label1: Transmitter
    num_tabs: '2'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: agcGain
    reference: '1.7'
    type: float
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: 1e0
    gain: '0.8'
    max_gain: '8'
    reference: '.8'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ToneLevel * TXTone
    freq: ToneFreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=RadioHatCodec,DEV=0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=RadioHatCodec,DEV=1
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Volume
    high_cutoff_freq: HPF
    low_cutoff_freq: LPF
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '100'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1- rxbalance/2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1+rxbalance/2
    type: float
  states: {}
- name: blocks_mute_xx_1
  id: blocks_mute_xx
  parameters:
    mute: MuteMic
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '201'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '201'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_1_0
  id: hilbert_fc
  parameters:
    num_taps: '301'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: 1- txbalance/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000'
    decim: '1'
    gain: 1+txbalance/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: RXTXTabs@0:2,0,1,3
    label: level
    legend: 'False'
    showports: 'True'
    type: complex
    units: dBm
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-110'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: RXTXTabs@1:0,0,1,1
    label1: ''
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.05'
  states: {}

connections:
- [analog_agc2_xx_0, '0', audio_sink_1, '0']
- [analog_agc2_xx_1, '0', blocks_mute_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_1, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_multiply_const_vxx_1, '0']
- [audio_source_1, '0', analog_agc2_xx_1, '0']
- [band_pass_filter_0, '0', analog_agc2_xx_0, '0']
- [band_pass_filter_1, '0', hilbert_fc_1_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_1, '0', band_pass_filter_1, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_complex_to_imag_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_real_1, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', hilbert_fc_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', hilbert_fc_0, '0']
- [blocks_mute_xx_1, '0', blocks_add_xx_1, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [hilbert_fc_1, '0', blocks_complex_to_real_0, '0']
- [hilbert_fc_1_0, '0', blocks_complex_to_imag_1, '0']
- [hilbert_fc_1_0, '0', blocks_complex_to_real_1, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', audio_sink_0, '1']

metadata:
  file_format: 1
